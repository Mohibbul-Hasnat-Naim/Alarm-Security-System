#include <TypeDefine.h>
#include <Keypad.h>
#include <LiquidCrystal.h>
LiquidCrystal lcd(A1, A0, A5, A4, A3, A2);

#define led1 0
#define buzz 1
#define sensor 2

B checkPass = 0, changePass = 0, passFlag = 0;
B alarmMode = 0, changeMode = 0, alarmFlag = 0;
U8 curPos = 8;
String password = "1234";
String tempPassword = "";

const U8 ROWS = 4; //four rows
const U8 COLS = 4; //four columns

char keys[ROWS][COLS] = {
  {'7', '8', '9', 'A'},
  {'4', '5', '6', 'B'},
  {'1', '2', '3', 'C'},
  {'*', '0', '#', 'D'}
};
U8 rowPins[ROWS] = {12, 11, 10, 9}; //connect to the row pinouts of the keypad
U8 colPins[COLS] = {8, 7, 6, 5}; //connect to the column pinouts of the keypad

Keypad keypad = Keypad( makeKeymap(keys), rowPins, colPins, ROWS, COLS );

void setup()
{
  pinMode(led1, OUTPUT); pinMode(buzz, OUTPUT);
  digitalWrite(led1, 0); digitalWrite(buzz, 0);
  pinMode(sensor, INPUT_PULLUP);

  lcd.begin(16, 2);
  homeScr();
}

void loop()
{
  char key = keypad.getKey();  // Check for key press

  if (key)
  {
    if (key == 'D')
    {
      lcd.clear(); lcd.print("Alarm will be");
      lcd.setCursor(0, 1); lcd.print("activated in"); 

      U8 timeCount = 3;
      while (timeCount > 0)  // Countdown for 3 seconds
      {
        lcd.setCursor(13, 1); lcd.print(timeCount); 
        delay(1000);
        timeCount--;
        tone(buzz, 700, 100);
      }
      digitalWrite(led1, 1); // Activate Alarm System
      lcd.clear(); lcd.print("Alarm Activated!");
      alarmMode = 1;
      activateAlarm();
    }

    else if (key == 'B')
    {
      lcd.clear(); lcd.print("Current Password");
      lcd.setCursor(8, 1); lcd.print(">");
      changeMode = 1; curPos = 8;
      while (changeMode) {enterPassword();}
    }
  }
}
